# Keil uVision project ASM3_E2.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: P11_E2
  c flags: Optim=1 OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main_asm3e2.c base_lpc40xx.lib concatenar_cadenas.s
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
