# Keil uVision project 99.2_LCD I2C.uvprojx, settings and files
target LCD I2C Lib (6220000::V6.22::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lpc40xx_lcd_i2c (library)
  c flags: Optim=6 OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Base
    ./: error.c timer_lpc40xx.c
  group GPIO
    ./: gpio_lpc40xx.c iocon_lpc40xx.c
  group I2C
    ./: i2c_lpc40xx.c
  group LCD I2C
    ./: main_lcd_i2c.c lcd_hd44780_lpc40xx.c lcd_i2c_lpc40xx.c
  group Retarget ITM
    ./: retarget_itm.c
target LCD I2C Test (6180000::V6.18::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: as above
  output: lpc40xx_lcd_1604_i2c_test
  c flags: OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
