# Keil uVision project 99.7_RFID.uvprojx, settings and files
target RFID Lib (6220000::V6.22::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lpc40xx_spi (library)
  c flags: Optim=6 OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Base
    ./: error.c timer_lpc40xx.c
  group GLCD
    ./: sdram.c fuente_8x16.c fuente_12x24.c fuente_16x32.c glcd.c
  group GPIO
    ./: gpio_lpc40xx.c iocon_lpc40xx.c
  group GPIO Tarjeta
    ./: joystick.c leds.c
  group SPI
    ./: spi_lpc40xx.c
  group RFID
    ./: main_rfid.c mfrc522_lpc40xx.c mfrc522_lpc40xx_plantilla.c
target RFID Test (6220000::V6.22::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: as above
  output: lpc40xx_rfid
  c flags: Optim=6 OneElfS=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
