# Keil uVision project 03_Base_sin_timer.uvprojx, settings and files
target Base sin Timer Lib (6240000::V6.24::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: base_sin_timer_lpc40xx (library)
  c flags: Optim=6 OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Base
    ./: error.c
  group GLCD
    ./: sdram.c fuente_8x16.c fuente_12x24.c fuente_16x32.c glcd.c
  group GPIO
    ./: gpio_lpc40xx.c iocon_lpc40xx.c
  group GPIO Tarjeta
    ./: joystick.c leds.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
