# Keil uVision project 02.1_Tetris.uvprojx, settings and files
target Tetris Lib (6240000::V6.24::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tetris_lpc40xx (library)
  c flags: Optim=6 OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Base
    ./: error.c timer_lpc40xx.c
  group GLCD
    ./: sdram.c fuente_8x16.c fuente_12x24.c fuente_16x32.c glcd.c
  group GPIO
    ./: gpio_lpc40xx.c iocon_lpc40xx.c
  group GPIO Tarjeta
    ./: joystick.c leds.c
  group Tetris
    ./: bloque.c cubeta.c juego.c main_tetris.c marcador.c menu.c piezas.c
target Tetris Test (6240000::V6.24::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: as above
  output: tetris_lpc40xx
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
